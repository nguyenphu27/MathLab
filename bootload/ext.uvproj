# Keil uVision project ext.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ID2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: ext
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: EXT.C EXTTABL.A51 STARTEXT.A51
