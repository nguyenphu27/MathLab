# Keil uVision project boot.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ID2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: boot
  c flags: Optimize=6 SizeSpeed=1
  group Boot Loader
    ./: BOOT.C JUMPTAB.C STARTUP.A51
  group External Part
    ./: EXT.C
  group Documentation
    ./: ABSTRACT.TXT
